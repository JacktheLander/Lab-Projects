Vs 1 0 1
R1 1 2 2
r2 2 3 9
r3 3 4 8
R4 2 0 10
R5 3 0 4
I1 0 4 1
