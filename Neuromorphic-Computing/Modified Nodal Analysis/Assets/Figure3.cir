Vs 1 0 1
R1 1 2 2k
R2 2 3 4k
C1 2 0 8u
C2 3 0 12u
C3 3 4 10u
R3 0 4 5k
